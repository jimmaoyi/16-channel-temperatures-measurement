# IAR project ProjectDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; xSTM32F10X_HD; STM32F10X_MD; BSP_USART1; BSP_USART2; I2C_SOFTWARE_FLAG; xOLDLED
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\User\drivers; ..\..\Libraries\STM32F10x_StdPeriph_Driver\src; $PROJ_DIR$; ..\..\Libraries\CMSIS\CM3\CoreSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ProjectDemo.hex
  ILINK.IlinkOutputFile: ProjectDemo.out
  ILINK.IlinkIcfFile: ProjectDemo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; xSTM32F10X_HD; STM32F10X_MD; BSP_USART1; BSP_USART2; I2C_SOFTWARE_FLAG; xOLDLED
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xC.icf
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group DRIVERS
    ../../User/drivers/: bsp_timer.c bsp_usart.c spi.c
  group FWLIBARY
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_dma.h
  group PROJECT
    ./: main.c system_stm32f10x.c
